options:
  parameters:
    author: DF7CB
    generate_options: no_gui
    id: cw
    max_nouts: '500'
    output_language: python
    run_options: run
    title: CW Generator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: cw_audio_sink
  id: audio_sink
  parameters:
    device_name: pulse:tx0
    samp_rate: '48000'
  states: {}
- name: cw_modulator
  id: epy_block
  parameters:
    _source_code: |
      """
      CW Modulator Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """CW Modulator block"""

          def __init__(self, transition=1000):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CW Modulator',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # ramp up signal over this many ticks
              self.transition = transition
              self.level = 0
              self.keyed = False

              self.message_port_register_in(pmt.intern("key"))
              self.set_msg_handler(pmt.intern('key'), self.key)

          def key(self, msg):
              if pmt.is_pair(msg) and pmt.car(msg) == pmt.intern('key'):
                  self.keyed = pmt.to_bool(pmt.cdr(msg))

          def work(self, input_items, output_items):
              for i in range(len(output_items[0])):
                  if self.keyed and self.level < self.transition:
                      self.level += 1
                  if not self.keyed and self.level > 0:
                      self.level -= 1
                  factor = 0.5 * (1 - np.cos(np.pi * self.level / self.transition))
                  output_items[0][i] = input_items[0][i] * factor
              return len(output_items[0])
    transition: '500'
  states: {}
- name: cw_source
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import serial

      class blk(gr.sync_block):
          """Read CW input from modified K3NG keyer"""

          def __init__(self, port='/dev/ttyUSBK3NG'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CW Source',
                  in_sig=None,
                  out_sig=None,
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.port = port

              self.message_port_register_out(pmt.intern("key"))

          def start(self):
              self.serial = serial.Serial(self.port, 1200)

              self.cwthread = threading.Thread(target=self.cw, daemon=True)
              self.cwthread.start()

          def set_key(self, key):
              self.message_port_pub(pmt.intern("key"),
                      pmt.cons(pmt.intern("key"), pmt.from_bool(key)))

          def cw(self):
              while True:
                  try:
                      x = self.serial.read()
                      if x in (b'^', b'_'):
                          self.set_key(x == b'^')
                  except Exception as e:
                      self.set_key(False) # turn signal off on error
                      print(e)
    port: '''/dev/ttyUSBK3NG'''
  states: {}
- name: pitch_source
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [cw_modulator, '0', cw_audio_sink, '0']
- [cw_source, key, blocks_message_debug_0, print]
- [cw_source, key, cw_modulator, key]
- [pitch_source, '0', cw_modulator, '0']

metadata:
  file_format: 1
