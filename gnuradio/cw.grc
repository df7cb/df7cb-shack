options:
  parameters:
    author: DF7CB
    generate_options: no_gui
    id: cw
    max_nouts: '500'
    output_language: python
    run_options: run
    title: CW Generator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '950'
    low_cutoff_freq: '750'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: cw_audio_sink
  id: audio_sink
  parameters:
    device_name: pulse:tx0
    samp_rate: '48000'
  states: {}
- name: cw_modulator
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.message_port_register_in(pmt.intern("cw_in"))
              self.set_msg_handler(pmt.intern('cw_in'), self.key)
              self.keyed = 0.0

          def key(self, msg):
              if pmt.car(msg) == pmt.intern('cw'):
                  self.keyed = pmt.to_float(pmt.cdr(msg))

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] * self.keyed
              return len(output_items[0])
  states: {}
- name: cw_source
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      import serial

      class blk(gr.sync_block):
          """Read CW input from modified K3NG keyer"""

          def __init__(self, port='/dev/ttyUSBK3NG'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CW Source',
                  in_sig=None,
                  out_sig=None,
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.port = port

              self.message_port_register_out(pmt.intern("cw_out"))

          def start(self):
              self.serial = serial.Serial(self.port, 1200)

              self.cwthread = threading.Thread(target=self.cw, daemon=True)
              self.cwthread.start()

          def set_ampl(self, ampl):
              self.message_port_pub(pmt.intern("cw_out"),
                      pmt.cons(pmt.intern('cw'), pmt.from_float(ampl)))

          def cw(self):
              while True:
                  try:
                      x = self.serial.read()
                      if x in (b'^', b'_'):
                          ampl = 0.5 if x == b'^' else 0.0
                          self.set_ampl(ampl)
                  except Exception as e:
                      self.set_ampl(0.0) # turn signal off on error
    port: '''/dev/ttyUSBK3NG'''
  states: {}
- name: pitch_source
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '850'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}

connections:
- [band_pass_filter_0, '0', cw_audio_sink, '0']
- [cw_modulator, '0', band_pass_filter_0, '0']
- [cw_source, cw_out, blocks_message_debug_0, print]
- [cw_source, cw_out, cw_modulator, cw_in]
- [pitch_source, '0', cw_modulator, '0']

metadata:
  file_format: 1
