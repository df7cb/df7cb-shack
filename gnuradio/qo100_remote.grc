options:
  parameters:
    author: DF7CB
    generate_options: no_gui
    id: qo100_remote
    output_language: python
    title: qo100
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: decim*48000
  states: {}
- name: zmq_watermark
  id: variable
  parameters:
    value: '4'
  states: {}
- name: limesdr_sink
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    comment: Transmitter
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '73'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch0: '2'
    pa_path_ch1: '1'
    rf_freq: 2400.250e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    ch_align: 'False'
    channel_mode: '0'
    comment: Receiver
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 739.75e6
    samp_rate: samp_rate
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.0.191:10024
    hwm: zmq_watermark
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://0.0.0.0:10010
    hwm: zmq_watermark
    timeout: '100'
    type: complex
  states: {}

connections:
- [limesdr_source, '0', zeromq_push_sink_0, '0']
- [zeromq_pull_source_0, '0', limesdr_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
