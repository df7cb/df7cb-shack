options:
  parameters:
    author: DM6AS, DF7CB
    generate_options: qt_gui
    id: qo100
    output_language: python
    title: qo100
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    label: af_gain
    start: '0'
    step: '1'
    stop: '200'
    value: '50'
  states: {}
- name: mag
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: vfo
  id: variable_qtgui_range
  parameters:
    label: vfo
    min_len: '150'
    start: '-10'
    step: '0.1'
    stop: '510'
    value: '40'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: mag
    freq: (vfo-250)*1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: mag
    freq: (250-vfo)*1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: mag
    freq: (250-40)*1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: pulse:rx2
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse:tx0.monitor
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '0'
    samp_rate: 48e3
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '50'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '73'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch0: '2'
    pa_path_ch1: '1'
    rf_freq: 2400.250e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 739.75e6
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 250e3
    fftsize: '1024'
    type: complex
    ymax: '-50'
    ymin: '-75'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 6e3
    fc: '0'
    fftsize: '1024'
    norm_window: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 250e3
    fftsize: '2048'
    int_max: '-45'
    int_min: '-75'
    type: complex
    update_time: '0.05'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '2'
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    fbw: '0.002'
    interp: '25'
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    fbw: '0.4'
    interp: '2'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    fbw: '0.4'
    interp: '1'
    type: ccf
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_1_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0_0_0, '1']
- [audio_source_0, '0', blocks_float_to_complex_1_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0_0_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_float_to_complex_1_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_swapiq_0, '0']
- [blocks_multiply_xx_0_0_0, '0', limesdr_sink_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0_0_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_swapiq_0, '0', blocks_add_xx_0, '1']
- [limesdr_source_0, '0', blocks_add_xx_0, '0']
- [limesdr_source_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [limesdr_source_0, '0', blocks_multiply_xx_0_0_0_0_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_complex_to_float_0_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
