options:
  parameters:
    author: DM6AS, DF7CB
    generate_options: qt_gui
    id: qo100
    output_language: python
    title: qo100
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 29,0,1,1
    label: af_gain
    start: '0'
    step: '5'
    stop: '200'
    value: '20'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '11'
  states: {}
- name: high_cutoff_gauge
  id: qtgui_levelgauge
  parameters:
    isVertical: 'False'
    maximum: '3000'
    minimum: '0'
    showValue: 'True'
    type: int
    value: '3000'
  states: {}
- name: low_cutoff_gauge
  id: qtgui_levelgauge
  parameters:
    isVertical: 'False'
    maximum: '3000'
    minimum: '0'
    showValue: 'True'
    type: int
    value: '0'
  states: {}
- name: mag
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: rx0_high_cutoff
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: rx0_low_cutoff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: decim*48e3
  states: {}
- name: tx_vfo
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    lbl: TX
    maxFreqHz: 510e3
    minFreqHz: '-10e3'
    value: 40e3
  states: {}
- name: vfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,0,1,1
    label: vfo
    min_len: '150'
    start: '-10'
    step: '0.1'
    stop: '510'
    value: '40'
  states: {state: disabled}
- name: vfo
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    lbl: RX
    maxFreqHz: 510e3
    minFreqHz: '-10e3'
    value: 40e3
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: control
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """TRX Control block"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Control',
                  in_sig=None,
                  out_sig=None,
              )

              self.message_port_register_in(pmt.intern("midi_in"))
              self.set_msg_handler(pmt.intern("midi_in"), self.midi_in)
              self.message_port_register_in(pmt.intern("rx_freq_in"))
              self.set_msg_handler(pmt.intern("rx_freq_in"), self.rx_freq_in)
              self.message_port_register_in(pmt.intern("tx_freq_in"))
              self.set_msg_handler(pmt.intern("tx_freq_in"), self.tx_freq_in)

              self.message_port_register_out(pmt.intern("rx_freq_out"))
              self.message_port_register_out(pmt.intern("tx_freq_out"))
              self.message_port_register_out(pmt.intern("rx0_low_cutoff"))
              self.message_port_register_out(pmt.intern("rx0_high_cutoff"))
              self.message_port_register_out(pmt.intern("midi_out"))

              self.rx_freq = 40000
              self.tx_freq = 40000
              self.filter_center = 850
              self.filter_bw = 3000

              self.sync_a = True

          def note_on(self, note, velocity):
              self.message_port_pub(pmt.intern("midi_out"),
                      pmt.cons(pmt.intern('note_on'),
                          pmt.cons(pmt.from_long(note), pmt.from_long(velocity))))

          def start(self):
              self.note_on(35, 127) # Sync A
              self.set_rx_freq(self.rx_freq)

          def set_rx_freq(self, freq):
              self.rx_freq = min(max(freq, -10000), 510000)
              self.message_port_pub(pmt.intern("rx_freq_out"), pmt.cons(pmt.intern('freq'), pmt.from_long(freq)))
              if self.sync_a:
                  self.set_tx_freq(self.rx_freq)

          def set_tx_freq(self, freq):
              self.tx_freq = min(max(freq, -10000), 510000)
              self.message_port_pub(pmt.intern("tx_freq_out"), pmt.cons(pmt.intern('freq'), pmt.from_long(freq)))
              # FT8 indicator LED
              self.note_on(2, 127 if freq == 40000 else 0)
              self.note_on(6, 127 if freq == 40000 else 0) # shift-KP 2 A

          def rx_freq_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('freq'):
                  self.rx_freq = int(pmt.to_double(pmt.cdr(msg)))
                  #if self.sync_a:
                  #    self.set_tx_freq(self.rx_freq)

          def tx_freq_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('freq'):
                  self.tx_freq = int(pmt.to_double(pmt.cdr(msg)))

          def midi_in(self, msg):
              if not msg.is_pair(): return
              msgtype = str(pmt.car(msg))

              if msgtype == 'control_change':
                  payload = pmt.cdr(msg)
                  control = pmt.to_long(pmt.car(payload))
                  value = pmt.to_long(pmt.cdr(payload))

                  if control == 48: # jog A
                      delta = value if value < 64 else value - 128
                      self.set_rx_freq(self.rx_freq + delta * 20)

                  elif control == 55: # shift-jog a
                      delta = value if value < 64 else value - 128
                      if self.sync_a:
                          self.sync_a = False
                          self.note_on(35, 0)
                      self.set_tx_freq(self.tx_freq + delta * 20)

                  elif control in (59, 60): # medium A, bass A
                      if control == 59:
                          self.filter_center = 100 + int(2800 * (value / 127.0))
                      if control == 60:
                          self.filter_bw = 100 + int(2900 * (value / 127.0))

                      low_cutoff = max(self.filter_center - self.filter_bw // 2, 0)
                      high_cutoff = min(self.filter_center + self.filter_bw // 2, 3000)

                      self.message_port_pub(pmt.intern("rx0_low_cutoff"), pmt.cons(pmt.intern('value'), pmt.from_long(low_cutoff)))
                      self.message_port_pub(pmt.intern("rx0_high_cutoff"), pmt.cons(pmt.intern('value'), pmt.from_long(high_cutoff)))

              elif msgtype == 'note_on':
                  payload = pmt.cdr(msg)
                  note = pmt.to_long(pmt.car(payload))
                  velocity = pmt.to_long(pmt.cdr(payload))

                  if note == 35 and velocity == 127: # Sync A
                      self.sync_a = not self.sync_a
                      self.note_on(35, 127 if self.sync_a else 0)
                      if self.sync_a:
                          self.set_tx_freq(self.rx_freq)

                  if note == 2 and velocity == 127: # KP 2 A
                      self.sync_a = True
                      self.note_on(35, 127)
                      self.set_rx_freq(40000)


      if __name__ == '__main__':
          blk()
  states: {}
- name: limesdr_sink
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '73'
    gain_dB_ch1: '30'
    oversample: '0'
    pa_path_ch0: '2'
    pa_path_ch1: '1'
    rf_freq: 2400.250e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 739.75e6
    samp_rate: samp_rate
  states: {}
- name: midi_block
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import mido
      import threading

      class blk(gr.sync_block):
          """MIDI Source block"""

          def __init__(self, midi_port='DJControl Compact:DJControl Compact DJControl Com'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='MIDI Source',
                  in_sig=None,
                  out_sig=None,
              )
              self.midi_port = midi_port

              self.message_port_register_in(pmt.intern("midi_in"))
              self.set_msg_handler(pmt.intern("midi_in"), self.midi_message)
              self.message_port_register_out(pmt.intern("midi_out"))

          def start(self):
              self.midiport = mido.open_ioport(self.midi_port)

              self.midithread = threading.Thread(target=self.midi, daemon=True)
              self.midithread.start()

          def midi(self):
              for msg in self.midiport:

                  if msg.type == 'control_change':
                      self.message_port_pub(pmt.intern("midi_out"),
                              pmt.cons(pmt.intern('control_change'),
                                  pmt.cons(pmt.from_long(msg.control), pmt.from_long(msg.value))))

                  elif msg.type == 'note_on':
                      self.message_port_pub(pmt.intern("midi_out"),
                              pmt.cons(pmt.intern('note_on'),
                                  pmt.cons(pmt.from_long(msg.note), pmt.from_long(msg.velocity))))
                  else:
                      self.message_port_pub(pmt.intern("midi_out"), pmt.string_to_symbol(str(msg)))

          def midi_message(self, msg):
              if not msg.is_pair(): return
              msgtype = str(pmt.car(msg))

              if msgtype == 'note_on':
                  payload = pmt.cdr(msg)
                  note = pmt.to_long(pmt.car(payload))
                  velocity = pmt.to_long(pmt.cdr(payload))

                  self.midiport.send(mido.Message('note_on', note=note, velocity=velocity))

      if __name__ == '__main__':
          blk()
    midi_port: '''DJControl Compact:DJControl Compact DJControl Com'''
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 250e3
    fftsize: '2048'
    gui_hint: 0,0,14,1
    int_max: '-45'
    int_min: '-75'
    type: complex
    update_time: '0.05'
  states: {}
- name: rx0_high_cutoff_setter
  id: blocks_msgpair_to_var
  parameters:
    target: rx0_high_cutoff
  states: {}
- name: rx0_low_cutoff_setter
  id: blocks_msgpair_to_var
  parameters:
    target: rx0_low_cutoff
  states: {}
- name: rx_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 250e3
    fftsize: '1024'
    type: complex
    ymax: '-50'
    ymin: '-75'
  states: {state: disabled}
- name: rx_resampler
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: decim
    type: ccc
  states: {}
- name: tx_audio_source
  id: audio_source
  parameters:
    device_name: pulse:tx0.monitor
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: tx_bandpass
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '0'
    samp_rate: 48e3
    type: interp_fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: tx_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: tx_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: tx_vfo_signal_source
  id: analog_sig_source_x
  parameters:
    amp: mag
    freq: tx_vfo - 250e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo0_audio_sink
  id: audio_sink
  parameters:
    device_name: pulse
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: vfo0_bandpass
  id: band_pass_filter
  parameters:
    decim: decim
    gain: af_gain
    high_cutoff_freq: rx0_high_cutoff
    low_cutoff_freq: rx0_low_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: vfo0_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: vfo0_scope
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 24e3
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 15,0,14,1
    legend: 'False'
    name: ''
    norm_window: 'True'
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HAMMING
    ymax: '-40'
    ymin: '-86'
  states: {}
- name: vfo0_scope_bandpass
  id: band_pass_filter
  parameters:
    decim: 2*decim
    gain: '1'
    high_cutoff_freq: 12e3
    low_cutoff_freq: '-12e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: vfo0_signal_source
  id: analog_sig_source_x
  parameters:
    amp: mag
    freq: 250e3-vfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo0_to_float
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: vfo0_waterfall_add
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: vfo0_waterfall_atten
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: complex
  states: {}
- name: vfo2_audio_sink
  id: audio_sink
  parameters:
    device_name: pulse:rx2
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: vfo2_bandpass
  id: band_pass_filter
  parameters:
    decim: decim
    gain: '10'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: vfo2_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: vfo2_signal_source
  id: analog_sig_source_x
  parameters:
    amp: mag
    freq: 250e3-40e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo2_to_float
  id: blocks_complex_to_float
  parameters: {}
  states: {}

connections:
- [blocks_swapiq_0, '0', vfo0_waterfall_atten, '0']
- [control, midi_out, midi_block, midi_in]
- [control, rx0_high_cutoff, high_cutoff_gauge, value]
- [control, rx0_high_cutoff, rx0_high_cutoff_setter, inpair]
- [control, rx0_low_cutoff, low_cutoff_gauge, value]
- [control, rx0_low_cutoff, rx0_low_cutoff_setter, inpair]
- [control, rx_freq_out, vfo, valuein]
- [control, tx_freq_out, tx_vfo, valuein]
- [limesdr_source, '0', rx_freq_sink, '0']
- [limesdr_source, '0', vfo0_mixer, '0']
- [limesdr_source, '0', vfo0_waterfall_add, '0']
- [limesdr_source, '0', vfo2_mixer, '0']
- [midi_block, midi_out, control, midi_in]
- [rx_resampler, '0', tx_mixer, '0']
- [tx_audio_source, '0', tx_to_complex, '0']
- [tx_bandpass, '0', rx_resampler, '0']
- [tx_mixer, '0', limesdr_sink, '0']
- [tx_to_complex, '0', tx_bandpass, '0']
- [tx_vfo, valueout, control, tx_freq_in]
- [tx_vfo_signal_source, '0', tx_mixer, '1']
- [vfo, valueout, blocks_message_debug_0, print]
- [vfo, valueout, control, rx_freq_in]
- [vfo0_bandpass, '0', vfo0_to_float, '0']
- [vfo0_mixer, '0', vfo0_bandpass, '0']
- [vfo0_mixer, '0', vfo0_scope_bandpass, '0']
- [vfo0_scope_bandpass, '0', vfo0_scope, '0']
- [vfo0_signal_source, '0', blocks_swapiq_0, '0']
- [vfo0_signal_source, '0', vfo0_mixer, '1']
- [vfo0_to_float, '0', vfo0_audio_sink, '0']
- [vfo0_waterfall_add, '0', qtgui_waterfall_sink_x_0, '0']
- [vfo0_waterfall_atten, '0', vfo0_waterfall_add, '1']
- [vfo2_bandpass, '0', vfo2_to_float, '0']
- [vfo2_mixer, '0', vfo2_bandpass, '0']
- [vfo2_signal_source, '0', vfo2_mixer, '1']
- [vfo2_to_float, '0', vfo2_audio_sink, '0']

metadata:
  file_format: 1
