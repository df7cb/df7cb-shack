options:
  parameters:
    author: DF7CB
    copyright: GPL-3+
    generate_options: no_gui
    id: ft84_decoder
    output_language: python
    run_options: run
    title: FT8 and FT4 Decoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: audio_source_rx2
  id: audio_source
  parameters:
    device_name: pulse:rx2.monitor
    samp_rate: '48000'
  states: {}
- name: cron
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import time
      import threading

      class blk(gr.basic_block):
          """Send Timed Msgs"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Send Timed Msgs',   # will show up in GRC
                  in_sig=None,
                  out_sig=None,
              )
              self.message_port_register_out(pmt.intern("cron_ft8"))
              self.message_port_register_out(pmt.intern("cron_ft4"))

          def start(self):
              self.cron_thread = threading.Thread(target=self.cron_ft8, daemon=True)
              self.cron_thread.start()
              self.cron_thread = threading.Thread(target=self.cron_ft4, daemon=True)
              self.cron_thread.start()

          def sleep(self, interval):
              time.sleep(interval - (time.time() % interval))
              return True

          def cron_ft8(self):
              while self.sleep(15):
                  self.message_port_pub(pmt.intern("cron_ft8"), pmt.intern("rotate_ft8"))

          def cron_ft4(self):
              while self.sleep(7.5):
                  self.message_port_pub(pmt.intern("cron_ft4"), pmt.intern("rotate_ft4"))

      if __name__ == "__main__":
          b = blk()
          b.cron_ft8()
  states: {}
- name: ft4_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /dev/null
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: ft84_init
  id: snippet
  parameters:
    code: |-
      import os

      # make top block accessible in rotate block
      self.rotate.tb = self

      # change to temp dir
      self.dir = '/run/user/1000/gnuradio'
      try: os.mkdir(self.dir)
      except: pass
      os.chdir(self.dir)
    priority: '1'
    section: main_after_init
  states: {}
- name: ft8_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /dev/null
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: rational_resampler_4
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: rotate
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import os
      import subprocess

      class blk(gr.basic_block):
          """Rotate wav files and feed them to jt9 for FT8 and FT4 decoding"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Rotate and Decode Wav File',   # will show up in GRC
                  in_sig=None,
                  out_sig=None,
              )

              self.message_port_register_in(pmt.intern("rotate_ft8"))
              self.set_msg_handler(pmt.intern("rotate_ft8"), self.rotate_ft8)
              self.message_port_register_in(pmt.intern("rotate_ft4"))
              self.set_msg_handler(pmt.intern("rotate_ft4"), self.rotate_ft4)

          def rotate_and_decode(self, mode, sink):
              # rotate file
              try: os.unlink(mode + ".wav")
              except: pass
              try: os.rename(mode + "-tmp.wav", mode + ".wav")
              except: pass

              # ask sink to re-open file
              sink.open(mode + "-tmp.wav")

              # decode it
              res = subprocess.run(["jt9", "--" + mode, mode + ".wav"], capture_output=True)
              out = res.stdout.decode()

              for line in out.split("\n"):
                  if line[:6] == "000000":
                      print(mode, line)

          def rotate_ft8(self, msg):
              self.rotate_and_decode("ft8", self.tb.ft8_sink)

          def rotate_ft4(self, msg):
              self.rotate_and_decode("ft4", self.tb.ft4_sink)

      if __name__ == "__main__":
          b = blk()
          b.rotate('foo')
  states: {}

connections:
- [audio_source_rx2, '0', rational_resampler_4, '0']
- [cron, cron_ft4, rotate, rotate_ft4]
- [cron, cron_ft8, rotate, rotate_ft8]
- [rational_resampler_4, '0', ft4_sink, '0']
- [rational_resampler_4, '0', ft8_sink, '0']

metadata:
  file_format: 1
