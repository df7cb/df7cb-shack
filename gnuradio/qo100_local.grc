options:
  parameters:
    author: DM6AS, DF7CB
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: qo100_local
    output_language: python
    title: qo100
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '11'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: high_cutoff_gauge
  id: qtgui_levelgauge
  parameters:
    gui_hint: 41,1,1,6
    isVertical: 'False'
    maximum: '3000'
    minimum: '0'
    showValue: 'True'
    type: int
    value: '3000'
  states: {}
- name: low_cutoff_gauge
  id: qtgui_levelgauge
  parameters:
    gui_hint: 40,1,1,6
    isVertical: 'False'
    maximum: '3000'
    minimum: '0'
    showValue: 'True'
    type: int
    value: '0'
  states: {}
- name: mag
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: mode_freq_offset
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 39,6,1,1
    initPressed: 'False'
    label: CW
    outputmsgname: freq_offset
    position: '3'
    pressed: '850'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: qtgui_dialgauge_0
  id: qtgui_dialgauge
  parameters:
    comment: WPM
    gui_hint: 39,5,1,1
    label: WPM
    maximum: '56'
    minimum: '0'
    msize: '80'
    showValue: 'True'
    type: int
    value: '24'
  states: {}
- name: qtgui_dialgauge_1
  id: qtgui_dialgauge
  parameters:
    comment: TX power
    gui_hint: 39,4,1,1
    label: TX Power
    maximum: '1.0'
    minimum: '0.0'
    msize: '80'
    showValue: 'True'
    type: real
    value: '0.1'
  states: {}
- name: qtgui_dialgauge_2
  id: qtgui_dialgauge
  parameters:
    comment: AF gain
    gui_hint: 39,3,1,1
    label: AF Gain
    maximum: '1.5'
    minimum: '0.0'
    msize: '80'
    showValue: 'True'
    type: real
    value: '1.0'
  states: {}
- name: qtgui_dialgauge_3
  id: qtgui_dialgauge
  parameters:
    comment: Filter Center
    gui_hint: 39,1,1,1
    label: Filter Center
    maximum: '3000'
    minimum: '0'
    msize: '80'
    showValue: 'True'
    type: int
    value: '1500'
  states: {}
- name: qtgui_dialgauge_4
  id: qtgui_dialgauge
  parameters:
    comment: Filter bandwidth
    gui_hint: 39,2,1,1
    label: Filter BW
    maximum: '3000'
    minimum: '0'
    msize: '80'
    showValue: 'True'
    type: int
    value: '3000'
  states: {}
- name: rx0_high_cutoff
  id: variable
  parameters:
    comment: |-
      RX bandpass
      high edge
    value: '3000'
  states: {}
- name: rx0_low_cutoff
  id: variable
  parameters:
    comment: |-
      RX bandpass
      low edge
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: decim*48e3
  states: {}
- name: tx_power
  id: variable
  parameters:
    comment: TX power
    value: '1.0'
  states: {}
- name: tx_vfo
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    comment: TX VFO frequency display
    gui_hint: 41,0,2,1
    lbl: TX
    maxFreqHz: 510e3
    minFreqHz: '-10e3'
    value: 40e3
  states: {}
- name: vfo_a
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    comment: RX VFO frequency display
    gui_hint: 39,0,1,1
    lbl: 'VFO A: SSB, CW with filter'
    maxFreqHz: 510e3
    minFreqHz: '-10e3'
    value: 40e3
  states: {}
- name: vfo_b
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    ThousandsSeparator: '.'
    comment: RX VFO frequency display
    gui_hint: 40,0,1,1
    lbl: 'VFO B: Digital'
    maxFreqHz: 510e3
    minFreqHz: '-10e3'
    value: 40e3
  states: {}
- name: zmq_watermark
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1e-3'
    freq: rx0_low_cutoff - freq_offset
    offset: '0'
    phase: '0'
    samp_rate: 24e3
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1e-3'
    freq: rx0_high_cutoff - freq_offset
    offset: '0'
    phase: '0'
    samp_rate: 24e3
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_offset
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Frequency sink audio passband markers
    samples_per_second: 24e3
    type: complex
  states: {}
- name: control
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      import os
      import pulsectl

      # buttons (notes)
      MIDI_FT8_QRG = 2 # KP 2 A
      MIDI_SHIFT_FT8_QRG = 6 # Shift-KP 2 A
      MIDI_SYNC_A = 35
      MIDI_SHIFT_SYNC_A = 38
      MIDI_SYNC_B = 83
      MIDI_SHIFT_SYNC_B = 86
      MIDI_RECORD = 43

      MIDI_AUDIO_HEADPHONES = 49 # KP 1 B
      MIDI_AUDIO_SPEAKER = 51 # KP 3 B
      MIDI_AUDIO_STEREO = 52 # KP 4 B
      MIDI_AUDIOS = [MIDI_AUDIO_HEADPHONES, MIDI_AUDIO_STEREO, MIDI_AUDIO_SPEAKER]

      # controls
      MIDI_SHIFT = 47
      MIDI_VFO_A = 48 # Jog A
      MIDI_SHIFT_VFO_A = 55 # Shift-Jog A
      MIDI_VFO_B = 49 # Jog B
      MIDI_SHIFT_VFO_B = 56 # Shift-Jog B
      MIDI_POWER = 54 # Slider
      MIDI_VOLUME = 57 # Volume A
      MIDI_BANDPASS_CENTER = 59 # Medium A
      MIDI_BANDPASS_WIDTH = 60 # Bass A
      MIDI_WPM = 0x3D # Volume B
      MIDI_REPORT_ALL_CONTROLS = 0x7f

      def sign(i):
          if i < 0:
              return -1
          elif i > 0:
              return 1
          else:
              return 0

      class blk(gr.sync_block):
          """TRX Control block"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Control',
                  in_sig=None,
                  out_sig=None,
              )

              self.message_port_register_in(pmt.intern("midi_in"))
              self.set_msg_handler(pmt.intern("midi_in"), self.midi_in)
              self.message_port_register_in(pmt.intern("vfo_a_freq_in"))
              self.set_msg_handler(pmt.intern("vfo_a_freq_in"), self.vfo_a_freq_in)
              self.message_port_register_in(pmt.intern("vfo_b_freq_in"))
              self.set_msg_handler(pmt.intern("vfo_b_freq_in"), self.vfo_b_freq_in)
              self.message_port_register_in(pmt.intern("tx_freq_in"))
              self.set_msg_handler(pmt.intern("tx_freq_in"), self.tx_freq_in)

              self.message_port_register_out(pmt.intern("midi_out"))
              self.message_port_register_out(pmt.intern("vfo_a_freq_out"))
              self.message_port_register_out(pmt.intern("vfo_b_freq_out"))
              self.message_port_register_out(pmt.intern("tx_freq_out"))
              self.message_port_register_out(pmt.intern("wpm_out"))
              self.message_port_register_out(pmt.intern("filter_center_out"))
              self.message_port_register_out(pmt.intern("filter_bw_out"))
              self.message_port_register_out(pmt.intern("af_gain_out"))

              self.vfo_a_freq = 40000.0
              self.vfo_b_freq = 40000.0
              self.tx_freq = 40000.0
              self.filter_center = 850
              self.filter_bw = 3000
              self.record = False
              self.sync_a = None # start false so set_sync_a sets the LEDs
              self.sync_b = None
              self.vfo_a_dir = 0 # last tuning direction
              self.vfo_b_dir = 0 # last tuning direction

              self.pulse = None
              self.tx_audio_port = None
              self.rx_audio_port = None
              self.ft8_audio_port = None

          def note_on(self, note, velocity):
              self.message_port_pub(pmt.intern("midi_out"),
                      pmt.cons(pmt.intern('note_on'),
                          pmt.cons(pmt.from_long(note), pmt.from_long(velocity))))

          def start(self):

              # Audio
              self.pulse = pulsectl.Pulse('qo100')

              for port in self.pulse.source_output_list():
                  # device.description: ALSA Capture [python3.13]
                  desc = port.proplist.get('device.description')
                  if desc and desc.startswith("ALSA Capture [python"):
                      self.tx_audio_port = port
                      print("TX port:", self.tx_audio_port)
                      self.set_audio_input('tx0')
                      break

              for port in self.pulse.sink_input_list():
                  # device.description: ALSA Playback [python3.13]
                  desc = port.proplist.get('device.description')
                  if desc and desc.startswith("ALSA Playback [python"):
                      if "remote.name" in port.proplist: # "pipewire-0" on the FT8 sink
                          self.ft8_audio_port = port
                          print("FT8 port:", self.ft8_audio_port)
                          # need to restore volume since pipewire can't tell the ports apart and randomly remembers the last setting from either
                          self.ft8_audio_port.volume.value_flat = 1.0
                          self.pulse.sink_input_volume_set(self.ft8_audio_port.index, self.ft8_audio_port.volume)
                          # connect to rx2
                          rx2_sink = self.pulse.get_sink_by_name("rx2")
                          self.pulse.sink_input_move(self.ft8_audio_port.index, rx2_sink.index)
                      elif self.rx_audio_port is None:
                          self.rx_audio_port = port
                          print("RX port:", self.rx_audio_port)
                          # volume will be set by polling the current console settings
                          # connect to sink
                          self.set_audio_output(MIDI_AUDIO_SPEAKER, 'Internes Audio')

              # MIDI
              self.set_vfo_a_freq(40000.0)
              self.set_vfo_b_freq(40000.0)
              self.set_tx_freq(40000.0)
              self.set_sync_a(True) # disables Sync B
              self.set_record(False)

              # read out knobs and slider on startup
              self.message_port_pub(pmt.intern("midi_out"),
                      pmt.cons(pmt.intern('control_change'),
                          pmt.cons(pmt.from_long(MIDI_REPORT_ALL_CONTROLS), pmt.from_long(127))))

              # without this, the spectrum display updates only once per second (GR bug?)
              #self.tb.vfo0_spectrum.set_fft_size(2048)

              # create temp directory
              try: os.mkdir("/run/user/1000/gnuradio")
              except: pass

          def set_audio_volume(self, new_volume):
              try:
                  #rx_sink = self.pulse.sink_default_get()
                  #rx_sink.volume.value_flat = new_volume
                  #self.pulse.sink_volume_set(rx_sink.index, rx_sink.volume)
                  self.rx_audio_port.volume.value_flat = new_volume
                  self.pulse.sink_input_volume_set(self.rx_audio_port.index, self.rx_audio_port.volume)
                  self.message_port_pub(pmt.intern("af_gain_out"),
                      pmt.cons(pmt.intern('value'), pmt.from_double(new_volume)))

              except Exception as e:
                  print("Error setting volume:", e)

          def set_audio_output(self, midi_key, sink_name):
              try:
                  for sink in self.pulse.sink_list():
                      if sink_name in sink.description:
                          self.pulse.sink_input_move(self.rx_audio_port.index, sink.index)
                          break

                  for key in MIDI_AUDIOS:
                      self.note_on(key, 127 if key == midi_key else 0)

              except Exception as e:
                  print(f"Error setting audio output to {sink_name}:", e)

          def set_audio_input(self, source_name):
              try:
                  for source in self.pulse.source_list():
                      if source.description.startswith(source_name):
                          self.pulse.source_output_move(self.tx_audio_port.index, source.index)
                          break

              except Exception as e:
                  print(f"Error setting audio input to {source_name}:", e)

          def set_record(self, record):
              self.record = record
              self.note_on(MIDI_RECORD, 127 if self.record else 0)
              if self.record:
                  self.set_audio_input(self.pulse.source_default_get().description)
              else:
                  self.set_audio_input('Monitor of tx0')

          def set_vfo_a_freq(self, freq):
              self.message_port_pub(pmt.intern("vfo_a_freq_out"),
                      pmt.cons(pmt.intern('freq'), pmt.from_double(freq)));

          def set_vfo_b_freq(self, freq):
              self.message_port_pub(pmt.intern("vfo_b_freq_out"),
                      pmt.cons(pmt.intern('freq'), pmt.from_double(freq)));

          def set_tx_freq(self, freq):
              self.message_port_pub(pmt.intern("tx_freq_out"),
                      pmt.cons(pmt.intern('freq'), pmt.from_double(freq)));

          def set_wpm(self, wpm):
              self.message_port_pub(pmt.intern("wpm_out"),
                      pmt.cons(pmt.intern('value'), pmt.from_double(wpm)));

          def set_sync_a(self, sync_a):
              if self.sync_a != sync_a:
                  self.sync_a = sync_a
                  self.note_on(MIDI_SYNC_A, 127 if sync_a else 0)
                  self.note_on(MIDI_SHIFT_SYNC_A, 127 if sync_a else 0)
                  if sync_a:
                      self.set_sync_b(False)
                      self.set_tx_freq(self.vfo_a_freq)

          def set_sync_b(self, sync_b):
              if self.sync_b != sync_b:
                  self.sync_b = sync_b
                  self.note_on(MIDI_SYNC_B, 127 if sync_b else 0)
                  self.note_on(MIDI_SHIFT_SYNC_B, 127 if sync_b else 0)
                  if sync_b:
                      self.set_sync_a(False)
                      self.set_tx_freq(self.vfo_b_freq)

          def vfo_a_freq_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('freq'):
                  self.vfo_a_freq = int(pmt.to_double(pmt.cdr(msg)))
                  if self.sync_a:
                      self.set_tx_freq(self.vfo_a_freq)

          def vfo_b_freq_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('freq'):
                  self.vfo_b_freq = int(pmt.to_double(pmt.cdr(msg)))
                  if self.sync_b:
                      self.set_tx_freq(self.vfo_b_freq)

          def tx_freq_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('freq'):
                  tx_freq = int(pmt.to_double(pmt.cdr(msg)))

                  if (tx_freq == 40000) != (self.tx_freq == 40000):
                      # FT8 frequency indicator LED
                      self.note_on(MIDI_FT8_QRG, 127 if tx_freq == 40000 else 0)
                      self.note_on(MIDI_SHIFT_FT8_QRG, 127 if tx_freq == 40000 else 0)

                  self.tx_freq = tx_freq

                  if self.tx_freq != self.vfo_a_freq:
                      self.set_sync_a(False)
                  if self.tx_freq != self.vfo_b_freq:
                      self.set_sync_b(False)

                  freqfile = open("/run/user/1000/gnuradio/qo100.qrg", "w")
                  freqfile.write(str(tx_freq + 2400000000) + "\n")
                  # fake frequency on 10m so tlf can deal with it
                  #freqfile.write(str(tx_freq + 28000000) + "\n")
                  freqfile.close()

          def midi_in(self, msg):
              if not msg.is_pair(): return
              msgtype = str(pmt.car(msg))

              if msgtype == 'control_change':
                  payload = pmt.cdr(msg)
                  control = pmt.to_long(pmt.car(payload))
                  value = pmt.to_long(pmt.cdr(payload))

                  if control == MIDI_VFO_A: # jog A
                      delta = value if value < 64 else value - 128
                      if sign(delta) != self.vfo_a_dir: # compensate for 2 (or 126) output on direction change
                          delta += self.vfo_a_dir
                          self.vfo_a_dir = sign(delta)
                      self.set_vfo_a_freq(self.vfo_a_freq + delta * 10)

                  elif control == MIDI_VFO_B: # jog B
                      delta = value if value < 64 else value - 128
                      if sign(delta) != self.vfo_b_dir: # compensate for 2 (or 126) output on direction change
                          delta += self.vfo_b_dir
                          self.vfo_b_dir = sign(delta)
                      self.set_vfo_b_freq(self.vfo_b_freq + delta * 10)

                  elif control == MIDI_SHIFT_VFO_A and value != 64: # shift-jog a (64 reported on all-buttons-readout, ignore that)
                      delta = value if value < 64 else value - 128
                      if sign(delta) != self.vfo_a_dir: # compensate for 2 (or 126) output on direction change
                          delta += self.vfo_a_dir
                          self.vfo_a_dir = sign(delta)
                      self.set_sync_a(False)
                      self.set_sync_b(False)
                      self.set_tx_freq(self.tx_freq + delta * 10)

                  elif control == MIDI_SHIFT_VFO_B and value != 64: # shift-jog a (64 reported on all-buttons-readout, ignore that)
                      delta = value if value < 64 else value - 128
                      if sign(delta) != self.vfo_b_dir: # compensate for 2 (or 126) output on direction change
                          delta += self.vfo_b_dir
                          self.vfo_b_dir = sign(delta)
                      self.set_sync_a(False)
                      self.set_sync_b(False)
                      self.set_tx_freq(self.tx_freq + delta * 10)

                  elif control == MIDI_VOLUME:
                      self.set_audio_volume(value / 100.0) # 0 .. 127%

                  elif control == MIDI_WPM:
                      wpm = round(6.0 + 42.0 * value / 127.0) # 0 .. 127% -> 6..48 wpm
                      self.set_wpm(wpm)

                  elif control in (MIDI_BANDPASS_CENTER, MIDI_BANDPASS_WIDTH): # medium A, bass A
                      if control == MIDI_BANDPASS_CENTER:
                          self.filter_center = 1500 + 20 * (value - 64)
                          self.message_port_pub(pmt.intern("filter_center_out"),
                              pmt.cons(pmt.intern('value'), pmt.from_double(self.filter_center)))
                      if control == MIDI_BANDPASS_WIDTH:
                          if value < 127 - 36: # first 36 steps are 30Hz, the rest 20Hz
                              self.filter_bw = 3000 - 360 - 20 * (127 - value)
                          else:
                              self.filter_bw = 3000 - 30 * (127 - value)
                          self.message_port_pub(pmt.intern("filter_bw_out"),
                              pmt.cons(pmt.intern('value'), pmt.from_double(self.filter_bw)))

                      low_cutoff = max(self.filter_center - self.filter_bw // 2, 0)
                      high_cutoff = min(self.filter_center + self.filter_bw // 2, 3000)
                      self.tb.set_rx0_low_cutoff(low_cutoff)
                      self.tb.set_rx0_high_cutoff(high_cutoff)

                  elif control == MIDI_POWER:
                      power = 0.1 + 0.9 * (value/127.0)
                      self.tb.set_tx_power(power)

                  else:
                      print("Unknown MIDI control_change:", control, value)

              elif msgtype == 'note_on':
                  payload = pmt.cdr(msg)
                  note = pmt.to_long(pmt.car(payload))
                  velocity = pmt.to_long(pmt.cdr(payload))

                  if velocity != 127: # ignore key releases
                      return

                  if note == MIDI_SYNC_A: # Sync A
                      self.set_sync_a(not self.sync_a)

                  elif note == MIDI_SYNC_B: # Sync B
                      self.set_sync_b(not self.sync_b)

                  elif note == MIDI_SHIFT_SYNC_A: # Shift-Sync A
                      self.set_vfo_a_freq(self.tx_freq) # set RX from TX
                      self.set_sync_a(True)

                  elif note == MIDI_SHIFT_SYNC_B: # Shift-Sync A
                      self.set_vfo_b_freq(self.tx_freq) # set RX from TX
                      self.set_sync_b(True)

                  elif note == MIDI_FT8_QRG: # KP 2 A
                      self.set_vfo_b_freq(40000)
                      self.set_sync_b(True)
                      self.set_record(False)

                  elif note == MIDI_AUDIO_HEADPHONES: # KP 1 A
                      self.set_audio_output(MIDI_AUDIO_HEADPHONES, 'Plantronics')

                  elif note == MIDI_AUDIO_STEREO: # KP 3 A
                      self.set_audio_output(MIDI_AUDIO_STEREO, 'Internes Audio Analog Stereo')

                  elif note == MIDI_AUDIO_SPEAKER: # KP 4 A
                      self.set_audio_output(MIDI_AUDIO_SPEAKER, 'Unitek Y')

                  elif note == MIDI_RECORD: # REC
                      self.set_record(not self.record)

                  elif note == MIDI_SHIFT: # ignore
                      pass

                  else:
                      print("Unknown MIDI note_on:", note, velocity)

              else:
                  print("Unknown MIDI message type:", msgtype)

      if __name__ == '__main__':
          blk()
    comment: Control logic
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: 250e3
    freq_span: samp_rate
  states: {state: disabled}
- name: ft4_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: FT4 file output
    file: /dev/null
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: ft84_cron
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import time
      import threading

      class blk(gr.basic_block):
          """Send Timed Msgs"""

          def __init__(self):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Send Timed Msgs',   # will show up in GRC
                  in_sig=None,
                  out_sig=None,
              )
              self.message_port_register_out(pmt.intern("cron_ft8"))
              self.message_port_register_out(pmt.intern("cron_ft4"))

          def start(self):
              self.cron_thread = threading.Thread(target=self.cron_ft8, daemon=True)
              self.cron_thread.start()
              self.cron_thread = threading.Thread(target=self.cron_ft4, daemon=True)
              self.cron_thread.start()

          def sleep(self, interval):
              time.sleep(interval - (time.time() % interval))
              return True

          def cron_ft8(self):
              while self.sleep(15):
                  self.message_port_pub(pmt.intern("cron_ft8"), pmt.intern("rotate_ft8"))

          def cron_ft4(self):
              while self.sleep(7.5):
                  self.message_port_pub(pmt.intern("cron_ft4"), pmt.intern("rotate_ft4"))

      if __name__ == "__main__":
          b = blk()
          b.cron_ft8()
  states: {}
- name: ft84_rotate
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import os
      import subprocess
      import time

      class blk(gr.basic_block):
          """Rotate wav files and feed them to jt9 for FT8 and FT4 decoding"""

          def __init__(self, tmp_path='.'):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Rotate and Decode Wav File',   # will show up in GRC
                  in_sig=None,
                  out_sig=None,
              )
              self.tmp_path = tmp_path

              self.message_port_register_in(pmt.intern("rotate_ft8"))
              self.set_msg_handler(pmt.intern("rotate_ft8"), self.rotate_ft8)
              self.message_port_register_in(pmt.intern("rotate_ft4"))
              self.set_msg_handler(pmt.intern("rotate_ft4"), self.rotate_ft4)

              # remember if we saw decodes in the last cycle
              self.decode = { 'ft8': False, 'ft4': False }

          def start(self):
              # store all decodes in file in PWD
              self.all_txt = open("ft84.txt", "a")
              self.conn = None
              self.cur = None

              # change to tmp_path (jt9 leaves a few temp files around there)
              try: os.mkdir(self.tmp_path)
              except: pass
              os.chdir(self.tmp_path)

          def handle_line(self, mode, stamp, line):
              # jt9 out: 000000   3  0.3 1743 ~  CQ DF7CB JO31
              # ALL.TXT: 220321_131530  2400.040 Rx FT8      1  0.5  523 ES2KO LY1FX 73
              fields = line.split(None, 5)
              if len(fields) > 5 and fields[0] == "000000":
                  try:
                      db = int(fields[1])
                      dt = float(fields[2])
                      freq = int(fields[3])
                      prefix = f"{stamp} 2400.040 Rx {mode.upper()}"
                      data = f" {db:+3} {dt:+4} {freq:4} "
                      msg = fields[5].rstrip()

                      # file output
                      self.all_txt.write(prefix + data + msg + "\n")
                      self.all_txt.flush()

                      # terminal output
                      if mode == 'ft8':
                          if stamp[-2:] in ('00', '30'):
                              stampcolor = "\033[48;5;39m"
                          else:
                              stampcolor = "\033[48;5;42m"
                      elif mode == 'ft4':
                          if stamp[-2:] in ('00', '15', '30', '45'):
                              stampcolor = "\033[48;5;208m"
                          else:
                              stampcolor = "\033[48;5;220m"
                      if msg.startswith("DF7CB "): # received my call
                          start, end = "\033[48;5;226m", "\033[0m"
                      elif "DF7CB" in msg: # sent by myself
                          start, end = "\033[41m", "\033[0m"
                      else:
                          start, end = "", ""
                      print(f"{stampcolor}{prefix}\033[0m{data}{start}{msg}{end}", flush=True)

                      return True # successful decode
                  except:
                      pass
              return False

          def rotate_and_decode(self, mode, sink, interval):
              tmp_file = f"{mode}-tmp.wav"
              decode_file = f"{mode}.wav"

              # rotate file
              try: os.unlink(decode_file)
              except: pass
              try: os.rename(tmp_file, decode_file)
              except: pass

              # ask sink to re-open file
              sink.open(tmp_file)

              stamp = time.strftime('%F_%H%M%S', time.gmtime(time.time() - interval))

              # decode it
              res = subprocess.run(["jt9", "--" + mode, decode_file], capture_output=True)
              out = res.stdout.decode()

              decode = False
              for line in out.split("\n"):
                  # decode a line
                  decode |= self.handle_line(mode, stamp, line)

              # insert a separator line if we saw something in the last cycle, but this cycle was empty
              if not decode and self.decode[mode]:
                  print(flush=True)
              self.decode[mode] = decode

          def rotate_ft8(self, msg):
              self.rotate_and_decode("ft8", self.tb.ft8_sink, 15)

          def rotate_ft4(self, msg):
              self.rotate_and_decode("ft4", self.tb.ft4_sink, 7.5)
    comment: FT8/FT4 decoder control logic
    tmp_path: '''/run/user/1000/gnuradio'''
  states: {}
- name: ft8_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: FT8 file output
    file: /dev/null
    format: FORMAT_WAV
    samp_rate: '12000'
  states: {}
- name: inject_tb
  id: snippet
  parameters:
    code: |-
      # make top block accessible in control block
      self.control.tb = self
      # make top block accessible in ft84_rotate block
      self.ft84_rotate.tb = self
    section: main_after_init
  states: {}
- name: limesdr_source
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    ch_align: 'False'
    channel_mode: '0'
    comment: Receiver
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 739.75e6
    samp_rate: samp_rate
  states: {state: disabled}
- name: midi_block
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import mido
      import threading

      class blk(gr.sync_block):
          """MIDI Source block"""

          def __init__(self, midi_port='DJControl Compact:DJControl Compact DJControl Com'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='MIDI Source',
                  in_sig=None,
                  out_sig=None,
              )
              self.midi_port = midi_port

              self.message_port_register_in(pmt.intern("midi_in"))
              self.set_msg_handler(pmt.intern("midi_in"), self.midi_message)
              self.message_port_register_out(pmt.intern("midi_out"))

          def start(self):
              self.midiport = mido.open_ioport(self.midi_port)

              self.midithread = threading.Thread(target=self.midi, daemon=True)
              self.midithread.start()

          def midi(self):
              for msg in self.midiport:

                  if msg.type == 'control_change':
                      self.message_port_pub(pmt.intern("midi_out"),
                              pmt.cons(pmt.intern('control_change'),
                                  pmt.cons(pmt.from_long(msg.control), pmt.from_long(msg.value))))

                  elif msg.type == 'note_on':
                      self.message_port_pub(pmt.intern("midi_out"),
                              pmt.cons(pmt.intern('note_on'),
                                  pmt.cons(pmt.from_long(msg.note), pmt.from_long(msg.velocity))))
                  else:
                      self.message_port_pub(pmt.intern("midi_out"), pmt.string_to_symbol(str(msg)))

          def midi_message(self, msg):
              if not msg.is_pair(): return
              msgtype = str(pmt.car(msg))

              if msgtype == 'note_on':
                  payload = pmt.cdr(msg)
                  note = pmt.to_long(pmt.car(payload))
                  velocity = pmt.to_long(pmt.cdr(payload))

                  self.midiport.send(mido.Message('note_on', note=note, velocity=velocity))

              elif msgtype == 'control_change':
                  payload = pmt.cdr(msg)
                  control = pmt.to_long(pmt.car(payload))
                  value = pmt.to_long(pmt.cdr(payload))

                  self.midiport.send(mido.Message('control_change', control=control, value=value))

      if __name__ == '__main__':
          blk()
    comment: MIDI interface
    midi_port: '''DJControl Compact'''
  states: {}
- name: rational_resampler_4
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: rigctld
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      import socket
      import threading
      import re

      class Client(threading.Thread):
          def __init__(self, sock, address, block):
              threading.Thread.__init__(self)
              self.socket = sock
              self.address = address
              self.block = block

              self.band = 2_400_000_000 # remember the band the client wants to be on
              self.mode = "USB"
              self.passband = "3000"

          def reply(self, msg):
              self.socket.sendall((msg + "\r\n").encode("UTF-8"))

          def run(self):
              try:
                  while True:
                      data = self.socket.recv(128)
                      if len(data) == 0:
                          self.socket.close()
                          break

                      cmd = str(data.decode("utf-8")).strip()
                      #print("rigctld:", cmd)

                      if cmd == "":
                          pass
                      elif m := re.match(r"(\|?)f\b", cmd):
                          freq = self.band + self.block.freq
                          if self.mode == "CW":
                              freq += 850
                          if m.group(1):
                              self.reply(f"get_freq:|Frequency: {freq}|RPRT 0")
                          else:
                              self.reply(str(freq))
                      elif m := re.match(r"(\|?)F\s*(\d+)\b", cmd):
                          freq = int(m.group(2))
                          if self.mode == "CW":
                              freq -= 850
                          base_freq = freq % 500_000
                          self.band = freq - base_freq
                          self.block.message_port_pub(pmt.intern("freq_out"),
                                                      pmt.cons(pmt.intern('control_change'), pmt.from_long(base_freq)))
                          if m.group(1):
                              self.reply(f"set_freq: {freq}|RPRT 0")
                          else:
                              self.reply("RPRT 0")
                      elif m := re.match(r"l\s*KEYSPD\b", cmd):
                          self.reply(str(self.block.wpm))
                      elif m := re.match(r"(\|?)m\b", cmd):
                          self.reply(self.mode)
                          self.reply(self.passband)
                          if m.group(1):
                              self.reply(f"get_mode:|Mode: {self.mode}|Passband: {self.passband}|RPRT 0")
                          else:
                              self.reply("RPRT 0")
                      elif m := re.match(r"(\|?)M\s*(\S+)\s+(\S+)\b", cmd):
                          self.mode = m.group(2)
                          self.passband = m.group(3)
                          if m.group(1):
                              self.reply(f"set_mode: {self.mode} {self.passband}|RPRT 0")
                          else:
                              self.reply("RPRT 0")
                      elif m := re.match(r"q\b", cmd):
                          self.reply("RPRT 0")
                          self.socket.close()
                          break
                      elif m := re.match(r"s\b", cmd): # split mode
                          self.reply("0")
                          self.reply("None")
                      elif m := re.match(r"v\b", cmd):
                          self.reply("VFOA")
                      elif m := re.match(r"V\s*.+\b", cmd):
                          self.reply("RPRT 0")
                      elif m := re.match(r"\\chk_vfo\b", cmd):
                          self.reply("0")
                      elif m := re.match(r"\\get_lock_mode\b", cmd):
                          self.reply("0")
                          self.reply("RPRT 0")
                      elif m := re.match(r"\\get_powerstat\b", cmd):
                          self.reply("1")
                      elif m := re.match(r"\\dump_state\b", cmd):
                          self.reply("""\
      1
      1
      0
      150000.000000 1500000000.000000 0x1ff -1 -1 0x17e00007 0xf
      0 0 0 0 0 0 0
      150000.000000 1500000000.000000 0x1ff 5000 100000 0x17e00007 0xf
      0 0 0 0 0 0 0
      0x1ff 1
      0x1ff 0
      0 0
      0xc 2400
      0xc 1800
      0xc 3000
      0xc 0
      0x2 500
      0x2 2400
      0x2 50
      0x2 0
      0x10 300
      0x10 2400
      0x10 50
      0x10 0
      0x1 8000
      0x1 2400
      0x1 10000
      0x20 15000
      0x20 8000
      0x40 230000
      0 0
      9990
      9990
      10000
      0
      10 
      10 20 30 
      0xffffffffffffffff
      0xffffffffffffffff
      0xfffffffff7ffffff
      0xfffeff7083ffffff
      0xffffffffffffffff
      0xffffffffffffffbf""")
                          self.reply("done")
                      else:
                          print("Unknown rigctld command:", cmd)
                          self.reply("RPRT -1")
              except Exception as inst:
                  print(inst)
                  pass

              print("rigctld: client " + str(self.address) + " has disconnected")

      def newConnections(socket, block):
          #connections = []
          #total_connections = 0

          while True:
              sock, address = socket.accept()
              print("rigctld: new connection from", address)
              Client(sock, address, block).start()

      class blk(gr.sync_block):
          """Hamlib rigctld interface block"""

          def __init__(self, port=4536):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Hamlib rigctld interface',
                  in_sig=None,
                  out_sig=None,
              )

              self.port = port

              self.freq = 0
              self.wpm = 0

              self.message_port_register_in(pmt.intern("freq_in"))
              self.set_msg_handler(pmt.intern("freq_in"), self.freq_in)
              self.message_port_register_in(pmt.intern("wpm_in"))
              self.set_msg_handler(pmt.intern("wpm_in"), self.wpm_in)

              self.message_port_register_out(pmt.intern("freq_out"))

              self.tcpthread = threading.Thread(target=self.tcp, daemon=True)
              self.tcpthread.start()

          #def start(self):

          def freq_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('freq'):
                  self.freq = int(pmt.to_double(pmt.cdr(msg)))

          def wpm_in(self, msg):
              if msg.is_pair() and pmt.car(msg) == pmt.intern('value'):
                  self.wpm = int(pmt.to_double(pmt.cdr(msg)))

          def tcp(self):
              sock = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
              sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              sock.bind(("localhost", self.port))
              sock.listen(5)

              newConnectionsThread = threading.Thread(target = newConnections, args = (sock, self))
              newConnectionsThread.start()

      if __name__ == '__main__':
          blk()
    port: '4555'
  states: {}
- name: rx0_high_cutoff_to_msg
  id: blocks_var_to_msg
  parameters:
    msgname: value
    target: rx0_high_cutoff
  states: {}
- name: rx0_low_cutoff_to_msg
  id: blocks_var_to_msg
  parameters:
    msgname: value
    target: rx0_low_cutoff
  states: {}
- name: rx_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: 250e3
    fftsize: '1024'
    type: complex
    ymax: '-50'
    ymin: '-75'
  states: {state: disabled}
- name: rx_resampler
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: decim
    type: ccc
  states: {}
- name: rx_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Transponder waterfall
    fc: 250e3
    fftsize: '2048'
    gui_hint: 0,0,14,7
    int_max: '-50'
    int_min: '-80'
    showports: 'True'
    type: complex
    update_time: '0.15'
  states: {}
- name: tx_audio_source
  id: audio_source
  parameters:
    comment: Transmitter audio input
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: tx_bandpass
  id: band_pass_filter
  parameters:
    gain: tx_power
    high_cutoff_freq: '3000'
    interp: '1'
    low_cutoff_freq: '0'
    samp_rate: 48e3
    type: interp_fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: tx_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: tx_power_to_msg
  id: blocks_var_to_msg
  parameters:
    msgname: value
    target: tx_power
  states: {}
- name: tx_to_complex
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: tx_vfo_signal_source
  id: analog_sig_source_x
  parameters:
    amp: mag
    comment: TX VFO
    freq: tx_vfo - freq_offset - 250e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo0_audio_sink
  id: audio_sink
  parameters:
    comment: |-
      Main audio output
      (Device name empty)
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: vfo0_bandpass
  id: band_pass_filter
  parameters:
    comment: Audio output
    decim: decim
    gain: '20'
    high_cutoff_freq: rx0_high_cutoff
    low_cutoff_freq: rx0_low_cutoff
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: vfo0_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: vfo0_mixer_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: vfo0_scope_bandpass
  id: band_pass_filter
  parameters:
    decim: 2*decim
    gain: '1'
    high_cutoff_freq: 12e3
    low_cutoff_freq: '-12e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: vfo0_signal_source
  id: analog_sig_source_x
  parameters:
    amp: mag
    comment: 'VFO A: waterfall'
    freq: 250e3 - vfo_a
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo0_signal_source_0
  id: analog_sig_source_x
  parameters:
    amp: mag
    comment: 'VFO A: receiver BFO'
    freq: 250e3 - (vfo_a - freq_offset)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo0_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 24e3
    comment: Spectrum around VFO 0
    fc: 40e3
    fftsize: '2048'
    grid: 'True'
    gui_hint: 15,0,15,7
    legend: 'False'
    name: ''
    nconnections: '2'
    norm_window: 'True'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HAMMING
    ymax: '-50'
    ymin: '-94'
  states: {}
- name: vfo0_to_float
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: vfo0_waterfall_add
  id: blocks_add_xx
  parameters:
    comment: Display VFO 0 in waterfall
    type: complex
  states: {}
- name: vfo0_waterfall_atten
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.01'
    type: complex
  states: {}
- name: vfo2_audio_sink
  id: audio_sink
  parameters:
    comment: |-
      FT8/FT4 audio output
      (Device name "pipewire" 
      so we can tell it apart 
      from the main output)
    device_name: pipewire
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: vfo2_bandpass
  id: band_pass_filter
  parameters:
    comment: FT8/FT4 output
    decim: decim
    gain: '10'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '0'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: vfo2_mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: vfo2_signal_source
  id: analog_sig_source_x
  parameters:
    amp: mag
    comment: 'VFO B: FT8/FT4 receiver'
    freq: 250e3 - vfo_b
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: vfo2_to_float
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.0.11:10010
    comment: Network input
    hwm: zmq_watermark
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://0.0.0.0:10024
    hwm: zmq_watermark
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_swapiq_0, '0', vfo0_waterfall_atten, '0']
- [blocks_throttle2_0, '0', vfo0_spectrum, '1']
- [control, af_gain_out, qtgui_dialgauge_2, value]
- [control, filter_bw_out, qtgui_dialgauge_4, value]
- [control, filter_center_out, qtgui_dialgauge_3, value]
- [control, midi_out, midi_block, midi_in]
- [control, tx_freq_out, tx_vfo, valuein]
- [control, vfo_a_freq_out, vfo_a, valuein]
- [control, vfo_b_freq_out, vfo_b, valuein]
- [control, wpm_out, qtgui_dialgauge_0, value]
- [control, wpm_out, rigctld, wpm_in]
- [ft84_cron, cron_ft4, ft84_rotate, rotate_ft4]
- [ft84_cron, cron_ft8, ft84_rotate, rotate_ft8]
- [limesdr_source, '0', rx_freq_sink, '0']
- [limesdr_source, '0', vfo0_mixer, '0']
- [limesdr_source, '0', vfo0_waterfall_add, '0']
- [limesdr_source, '0', vfo2_mixer, '0']
- [midi_block, midi_out, blocks_message_debug_0, print]
- [midi_block, midi_out, control, midi_in]
- [mode_freq_offset, state, blocks_msgpair_to_var_0, inpair]
- [rational_resampler_4, '0', ft4_sink, '0']
- [rational_resampler_4, '0', ft8_sink, '0']
- [rigctld, freq_out, vfo_a, valuein]
- [rx0_high_cutoff_to_msg, msgout, high_cutoff_gauge, value]
- [rx0_low_cutoff_to_msg, msgout, low_cutoff_gauge, value]
- [rx_resampler, '0', tx_mixer, '0']
- [rx_waterfall, freq, vfo_a, valuein]
- [tx_audio_source, '0', tx_to_complex, '0']
- [tx_bandpass, '0', rx_resampler, '0']
- [tx_mixer, '0', zeromq_push_sink_0, '0']
- [tx_power_to_msg, msgout, qtgui_dialgauge_1, value]
- [tx_to_complex, '0', tx_bandpass, '0']
- [tx_vfo, valueout, control, tx_freq_in]
- [tx_vfo_signal_source, '0', tx_mixer, '1']
- [vfo0_bandpass, '0', vfo0_to_float, '0']
- [vfo0_mixer, '0', vfo0_scope_bandpass, '0']
- [vfo0_mixer_0, '0', vfo0_bandpass, '0']
- [vfo0_scope_bandpass, '0', vfo0_spectrum, '0']
- [vfo0_signal_source, '0', blocks_swapiq_0, '0']
- [vfo0_signal_source, '0', vfo0_mixer, '1']
- [vfo0_signal_source_0, '0', vfo0_mixer_0, '1']
- [vfo0_spectrum, freq, vfo0_spectrum, freq]
- [vfo0_spectrum, freq, vfo_a, valuein]
- [vfo0_to_float, '0', vfo0_audio_sink, '0']
- [vfo0_waterfall_add, '0', rx_waterfall, '0']
- [vfo0_waterfall_atten, '0', vfo0_waterfall_add, '1']
- [vfo2_bandpass, '0', vfo2_to_float, '0']
- [vfo2_mixer, '0', vfo2_bandpass, '0']
- [vfo2_signal_source, '0', vfo2_mixer, '1']
- [vfo2_to_float, '0', rational_resampler_4, '0']
- [vfo2_to_float, '0', vfo2_audio_sink, '0']
- [vfo_a, valueout, control, vfo_a_freq_in]
- [vfo_a, valueout, rigctld, freq_in]
- [vfo_a, valueout, vfo0_spectrum, freq]
- [vfo_b, valueout, control, vfo_b_freq_in]
- [zeromq_pull_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [zeromq_pull_source_0, '0', vfo0_mixer, '0']
- [zeromq_pull_source_0, '0', vfo0_mixer_0, '0']
- [zeromq_pull_source_0, '0', vfo0_waterfall_add, '0']
- [zeromq_pull_source_0, '0', vfo2_mixer, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
